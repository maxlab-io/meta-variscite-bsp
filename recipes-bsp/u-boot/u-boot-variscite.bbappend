SRC_URI += "file://dts_name.patch"